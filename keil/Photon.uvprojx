# Keil uVision project Photon.uvprojx, settings and files
target Photon (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: ALL_TEST_STM32H743 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  AfterMake: fromelf --text -a -c -o "$L@L.dis" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx
  c include: ../third_party/STM32H7xx_HAL_Driver/Inc;../third_party/STM32H7xx_HAL_Driver/Inc/Legacy;../third_party/CMSIS/Device/ST/STM32H7xx/Include;../third_party/CMSIS/Include;..\third_party\FreeRTOS\include;..\third_party\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\port\stm32h743\freertos;..\third_party\lwIP\src\include;..\port\stm32h743\lwip;..\third_party\lwIP;..\interface\GPIO;..\interface\UART;..\interface\FDCAN;..\interface\FLASH;..\interface\IIC;..\interface\SPI;..\interface\ETHERNET;..\interface\DELAY;..\drivers;..\port\stm32h743\bsp;..\port\stm32h743\system;..\app\app_core\Inc;..\app\share\Inc;..\Drivers\pcf8574;..\Drivers\battery;..\Drivers\iap;..\Drivers\light;..\Drivers\motor;..\Drivers\net;..\Drivers\ultrasonic;..\Drivers\eth_phy;..\port\freertos;..\port\lwip\arch;..\port\lwip\common;..\port\lwip
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Startup
    ../port/stm32h743/startup/: startup_stm32h743xx.s
  group ThirdParty/STM32H7xx_HAL_Driver
    ../third_party/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_adc.c stm32h7xx_ll_delayblock.c
  group ThirdParty/FreeRTOS/kernel
    ../third_party/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group ThirdParty/FreeRTOS/port
    ../third_party/FreeRTOS/portable/Common/: mpu_wrappers.c
    ../third_party/FreeRTOS/portable/MemMang/: heap_4.c
    ../third_party/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
  group ThirdParty/LWIP/src/api
    ../third_party/lwIP/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group ThirdParty/LWIP/src/core
    ../third_party/lwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../third_party/lwIP/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group ThirdParty/LWIP/src/netif
    ../third_party/lwIP/src/netif/: ethernet.c bridgeif.c bridgeif_fdb.c
  group Port/FreeRTOS
    ../port/freertos/: FreeRTOSConfig.c
  group Port/lwIP
    ../port/lwip/common/: lwip_port.c
    ../port/lwip/arch/: ethernetif.c sys_arch.c
  group Port/stm32h743
    ../port/stm32h743/system/: gpio.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c system_stm32h7xx.c
    ../port/stm32h743/bsp/: bsp_eth.c bsp_fdcan.c bsp_gpio.c bsp_i2c.c bsp_spi.c bsp_uart.c stm_flash.c
  group Interface
    ../interface/UART/: uart_dev.c
    ../interface/DELAY/: delay_dev.c
    ../interface/IIC/: i2c_dev.c my_i2c.c
    ../interface/ETHERNET/: eth_dev.c
    ../interface/FDCAN/: can_dev.c
    ../interface/FLASH/: flash_dev.c
    ../interface/GPIO/: gpio_dev.c
    ../interface/SPI/: spi_dev.c
  group Drivers
    ../drivers/eth_phy/: eth_phy.c
    ../drivers/pcf8574/: pcf8574.c
    ../drivers/net/: net1_dev.c net_dev.c
    ../drivers/battery/: battery_dev.c xingneng_dev.c
    ../drivers/iap/: iap.c
    ../drivers/light/: tm512ac_dev.c light_dev.c
    ../drivers/motor/: hub_motor_dev.c motor_dev.c
    ../drivers/ultrasonic/: dypa21_dev.c ultrasonic_dev.c
    ../Drivers/net/: tcp_echo.c
  group Application
    ../app/share/Src/: log_print.c match_mode.c
    ../app/app_core/Src/: app_manage.c app_version.c app_led.c app_network.c app_battery.c app_light.c app_motor.c app_ultrasonic.c
software components: CMSIS:CORE 4.3.0
